SRC_URI += "file://bsp.cfg \
            file://user_2018-01-24-20-10-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
